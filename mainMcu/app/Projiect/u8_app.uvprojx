# Keil uVision project u8_app.uvprojx, settings and files
target u8_app (5060020::V5.06 (build 20)::ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DG32F303 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\Library\Firmware\GD32F30x_standard_peripheral\Include;..\Library\Firmware\CMSIS;..\Src\BSP;..\FreeRTOSv10\FreeRTOS\include;..\FreeRTOSv10\FreeRTOS\CMSIS_RTOS;..\Src\Application;..\Src;..\Library\Firmware\CMSIS\GD\GD32F30x\Include;..\Src\Bsw
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../Src/: main.c
    ../Src/Application/: App_Main.c App_BlueProto.c App_NetProto.c App_CardBoardProto.c App_Upgrade.c App_ProductTest.c App.c
  group Bsw/Srv
    ../Src/Bsw/: BswSrv_ComTask.c BswSrv_NFCard_Task.c BswSrv_NetTask.c BswSrv_ProductTest.c BswSrv_WifiBlueTask.c BswSrv_FwUpgrade.c BswSrv_RF433.c BswSrv_CardBoard.c BswSrv_Air720.c BswSrv_WG215.c BswSrv_Key.c BswSrv_Aes.c BswSrv_FlashUsr.c BswSrv_System.c BswSrv.c
  group Bsw/Drv
    ../Src/BSP/: BswDrv_Rtc.c BswDrv_GPIO.c BswDrv_Timer.c BswDrv_Delay.c BswDrv_Watchdog.c BswDrv_Usart.c BswDrv_SPI.c BswDrv_IIC.c BswDrv_Adc.c BswDrv_FIFO.c BswDrv_nfc.c BswDrv_Debug.c BswDrv_IC_RF433.c BswDrv_SPI_Fm175xx.c BswDrv_Sys_Flash.c BswDrv_sc8042b.c BswDrv.c
  group StartUp
    ../Library/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    ../Library/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group FreeRTOS
    ../FreeRTOSv10/FreeRTOS/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOSv10/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
  group lib
    ../Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
