# Keil uVision project BootLoad.uvprojx, settings and files
target BootLoad (5060020::V5.06 (build 20)::ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DG32F303 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\Library\Firmware\GD32F30x_standard_peripheral\Include;..\Library\Firmware\CMSIS;..\Src\BSP;..\FreeRTOSv10\FreeRTOS\include;..\Src\Application;..\Src;..\Library\Firmware\CMSIS\GD\GD32F30x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../Src/: main.c
    ../Src/Application/: SysFlash.c upgrade.c
  group StartUo
    ../Library/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    ../Library/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group FreeRTOS
    ../FreeRTOSv10/FreeRTOS/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group lib
    ../Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
